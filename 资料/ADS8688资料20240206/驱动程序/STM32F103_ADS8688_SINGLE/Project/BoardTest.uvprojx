# Keil uVision project BoardTest.uvprojx, settings and files
target STM32_EXTInterrupt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_EXTInterrupt +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\DeviceSupport\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\User;..\CMSIS\CoreSupport;..\CMSIS;..\User\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c LED.c PeripheralInit.c Delay.c lze_lcd.c ads8688.c spi.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_spi.c
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/STM32F10x/: system_stm32f10x.c
  group Startup
    ../CMSIS/DeviceSupport/STM32F10x/: startup_stm32f10x_hd.s
